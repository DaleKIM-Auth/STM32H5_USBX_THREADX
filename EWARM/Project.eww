<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32H5_USBX_THREADX.ewp</path>
  </project>
  <batchBuild />
</workspace>
